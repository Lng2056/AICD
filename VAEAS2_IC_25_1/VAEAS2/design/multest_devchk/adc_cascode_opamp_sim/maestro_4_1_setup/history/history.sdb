<?xml version="1.0"?>
<setupdb version="7">history
	<active>Active Setup</active>
	<history>History
		<historyentry assemblerOrExplorer="assembler" roOrView="view" runningOrFinished="finished">Interactive.0
			<timestamp>Jul 25 19:50:57 2016</timestamp>
			<uuid>{34f097df-0556-4f4c-8041-72117cc494dd}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/servers/esd_noida/anthonys/VADEAssemblerS1/design/multest_devchk/adc_cascode_opamp_sim/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<psfdir>/servers/esd_noida/anthonys/VADEAssemblerS1/simulation/multest_devchk/adc_cascode_opamp_sim/maestro/results/maestro/$AXL_HISTORY_NAME</psfdir>
			<simdir>$AXL_PROJECT_DIR/multest_devchk/adc_cascode_opamp_sim/maestro/results/maestro/$AXL_HISTORY_NAME</simdir>
			<historyPsfSize></historyPsfSize>
		</historyentry>
		<historyentry assemblerOrExplorer="assembler" roOrView="view" runningOrFinished="finished">Interactive.1
			<timestamp>Aug 22 13:26:50 2023</timestamp>
			<uuid>{dbd87ebf-6a01-4706-ae76-0da3a31fec15}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/servers/esd_noida/saidarsh/VAEAS2/design/multest_devchk/adc_cascode_opamp_sim/maestro_4_1_setup/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<psfdir>/servers/esd_noida/saidarsh/VAEAS2/simulation/multest_devchk/adc_cascode_opamp_sim/maestro_4_1_setup/results/maestro/$AXL_HISTORY_NAME</psfdir>
			<simdir>$AXL_PROJECT_DIR/multest_devchk/adc_cascode_opamp_sim/maestro_4_1_setup/results/maestro/$AXL_HISTORY_NAME</simdir>
			<historyPsfSize></historyPsfSize>
		</historyentry>
		<historyentry assemblerOrExplorer="assembler" roOrView="view" runningOrFinished="finished">Interactive.2
			<timestamp>Jun 26 11:54:31 2025</timestamp>
			<uuid>{6a6a8d84-8173-4874-82ee-21bf0bfdd1a8}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/servers/esd_noida/saidarsh/VAEAS2/design/multest_devchk/adc_cascode_opamp_sim/maestro_4_1_setup/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<psfdir>/servers/esd_noida/saidarsh/VAEAS2/simulation/multest_devchk/adc_cascode_opamp_sim/maestro_4_1_setup/results/maestro/$AXL_HISTORY_NAME</psfdir>
			<simdir>$AXL_PROJECT_DIR/multest_devchk/adc_cascode_opamp_sim/maestro_4_1_setup/results/maestro/$AXL_HISTORY_NAME</simdir>
			<historyPsfSize>Not Computed</historyPsfSize>
		</historyentry>
		<historyentry assemblerOrExplorer="assembler" roOrView="view" runningOrFinished="finished">Interactive.3
			<timestamp>Jun 26 11:56:46 2025</timestamp>
			<uuid>{eb9f88d9-c7ae-4eeb-b3d5-67780b831c1f}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/servers/esd_noida/saidarsh/VAEAS2/design/multest_devchk/adc_cascode_opamp_sim/maestro_4_1_setup/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<psfdir>/servers/esd_noida/saidarsh/VAEAS2/simulation/multest_devchk/adc_cascode_opamp_sim/maestro_4_1_setup/results/maestro/$AXL_HISTORY_NAME</psfdir>
			<simdir>$AXL_PROJECT_DIR/multest_devchk/adc_cascode_opamp_sim/maestro_4_1_setup/results/maestro/$AXL_HISTORY_NAME</simdir>
			<historyPsfSize>Not Computed</historyPsfSize>
		</historyentry>
		<historyentry assemblerOrExplorer="assembler" roOrView="view" runningOrFinished="finished">Interactive.4
			<timestamp>Jul 1 16:34:30 2025</timestamp>
			<uuid>{d92e9d5f-9e5e-4bdc-900b-9c909e73651d}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/servers/esd_noida/saidarsh/VAEAS2/design/multest_devchk/adc_cascode_opamp_sim/maestro_4_1_setup/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<psfdir>/servers/esd_noida/saidarsh/VAEAS2/simulation/multest_devchk/adc_cascode_opamp_sim/maestro_4_1_setup/results/maestro/$AXL_HISTORY_NAME</psfdir>
			<simdir>$AXL_PROJECT_DIR/multest_devchk/adc_cascode_opamp_sim/maestro_4_1_setup/results/maestro/$AXL_HISTORY_NAME</simdir>
			<historyPsfSize>Not Computed</historyPsfSize>
		</historyentry>
	</history>
</setupdb>
