<?xml version="1.0"?>
<setupdb version="7">history
	<active>Active Setup</active>
	<history>History
		<historyentry assemblerOrExplorer="assembler" roOrView="view" runningOrFinished="finished">Interactive.0
			<timestamp>Jun 25 14:15:30 2025</timestamp>
			<uuid>{54305615-1967-4501-864e-e358dc33f10b}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/servers/esd_noida/saidarsh/VAEAS2/design/multest_devchk/adc_cascode_opamp_sim/maestro_3_1_setup/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<psfdir>/servers/esd_noida/saidarsh/VAEAS2/simulation/multest_devchk/adc_cascode_opamp_sim/maestro_3_1_setup/results/maestro/$AXL_HISTORY_NAME</psfdir>
			<simdir>$AXL_PROJECT_DIR/multest_devchk/adc_cascode_opamp_sim/maestro_3_1_setup/results/maestro/$AXL_HISTORY_NAME</simdir>
			<historyPsfSize>Not Computed</historyPsfSize>
		</historyentry>
		<historyentry assemblerOrExplorer="assembler" roOrView="view" runningOrFinished="finished">Interactive.1
			<timestamp>Jun 25 14:17:45 2025</timestamp>
			<uuid>{32eb1056-5c22-4fe8-9762-f5d237f56e95}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/servers/esd_noida/saidarsh/VAEAS2/design/multest_devchk/adc_cascode_opamp_sim/maestro_3_1_setup/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<psfdir>/servers/esd_noida/saidarsh/VAEAS2/simulation/multest_devchk/adc_cascode_opamp_sim/maestro_3_1_setup/results/maestro/$AXL_HISTORY_NAME</psfdir>
			<simdir>$AXL_PROJECT_DIR/multest_devchk/adc_cascode_opamp_sim/maestro_3_1_setup/results/maestro/$AXL_HISTORY_NAME</simdir>
			<historyPsfSize>Not Computed</historyPsfSize>
		</historyentry>
		<historyentry assemblerOrExplorer="assembler" roOrView="view" runningOrFinished="finished">Interactive.2
			<timestamp>Jun 25 14:18:18 2025</timestamp>
			<uuid>{8e445216-20e9-4e28-b6d7-17dda1a5cceb}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/servers/esd_noida/saidarsh/VAEAS2/design/multest_devchk/adc_cascode_opamp_sim/maestro_3_1_setup/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<psfdir>/servers/esd_noida/saidarsh/VAEAS2/simulation/multest_devchk/adc_cascode_opamp_sim/maestro_3_1_setup/results/maestro/$AXL_HISTORY_NAME</psfdir>
			<simdir>$AXL_PROJECT_DIR/multest_devchk/adc_cascode_opamp_sim/maestro_3_1_setup/results/maestro/$AXL_HISTORY_NAME</simdir>
			<historyPsfSize>Not Computed</historyPsfSize>
		</historyentry>
		<historyentry assemblerOrExplorer="assembler" roOrView="view" runningOrFinished="finished">Interactive.3
			<timestamp>Jul 1 15:27:05 2025</timestamp>
			<uuid>{d447e7a4-a749-404c-bd99-afb23aee4412}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/servers/esd_noida/saidarsh/VAEAS2/design/multest_devchk/adc_cascode_opamp_sim/maestro_3_1_setup/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<psfdir>/servers/esd_noida/saidarsh/VAEAS2/simulation/multest_devchk/adc_cascode_opamp_sim/maestro_3_1_setup/results/maestro/$AXL_HISTORY_NAME</psfdir>
			<simdir>$AXL_PROJECT_DIR/multest_devchk/adc_cascode_opamp_sim/maestro_3_1_setup/results/maestro/$AXL_HISTORY_NAME</simdir>
			<historyPsfSize>Not Computed</historyPsfSize>
		</historyentry>
		<historyentry assemblerOrExplorer="assembler" roOrView="view" runningOrFinished="finished">Interactive.4
			<timestamp>Jul 1 15:31:28 2025</timestamp>
			<uuid>{cdb71575-f569-4180-9a72-599b3196723f}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/servers/esd_noida/saidarsh/VAEAS2/design/multest_devchk/adc_cascode_opamp_sim/maestro_3_1_setup/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<psfdir>/servers/esd_noida/saidarsh/VAEAS2/simulation/multest_devchk/adc_cascode_opamp_sim/maestro_3_1_setup/results/maestro/$AXL_HISTORY_NAME</psfdir>
			<simdir>$AXL_PROJECT_DIR/multest_devchk/adc_cascode_opamp_sim/maestro_3_1_setup/results/maestro/$AXL_HISTORY_NAME</simdir>
			<historyPsfSize>Not Computed</historyPsfSize>
		</historyentry>
	</history>
</setupdb>
