<?xml version="1.0"?>
<setupdb version="7">history
	<active>Active Setup</active>
	<history>History
		<historyentry assemblerOrExplorer="assembler" roOrView="view" runningOrFinished="finished">Interactive.0
			<timestamp>Jul 25 19:50:57 2016</timestamp>
			<uuid>{492d4255-0e7f-44ee-83cd-166a07462d14}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/servers/esd_noida/anthonys/VADEAssemblerS1/design/multest_devchk/adc_cascode_opamp_sim/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<psfdir>/servers/esd_noida/anthonys/VADEAssemblerS1/simulation/multest_devchk/adc_cascode_opamp_sim/maestro/results/maestro/$AXL_HISTORY_NAME</psfdir>
			<simdir>$AXL_PROJECT_DIR/multest_devchk/adc_cascode_opamp_sim/maestro/results/maestro/$AXL_HISTORY_NAME</simdir>
			<historyPsfSize></historyPsfSize>
		</historyentry>
		<historyentry assemblerOrExplorer="assembler" roOrView="view" runningOrFinished="finished">Interactive.1
			<timestamp>Jul 25 20:02:47 2016</timestamp>
			<uuid>{e32e4990-f45f-40b9-949a-82f6d74e5f49}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/servers/esd_noida/anthonys/VADEAssemblerS1/design/multest_devchk/adc_cascode_opamp_sim/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<psfdir>/servers/esd_noida/anthonys/VADEAssemblerS1/simulation/multest_devchk/adc_cascode_opamp_sim/maestro/results/maestro/$AXL_HISTORY_NAME</psfdir>
			<simdir>$AXL_PROJECT_DIR/multest_devchk/adc_cascode_opamp_sim/maestro/results/maestro/$AXL_HISTORY_NAME</simdir>
			<historyPsfSize></historyPsfSize>
		</historyentry>
		<historyentry assemblerOrExplorer="assembler" roOrView="view" runningOrFinished="finished">Interactive.2
			<timestamp>Jul 1 16:35:55 2025</timestamp>
			<uuid>{51549e1b-41d1-413c-b72d-1bf39a12e01e}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/servers/esd_noida/saidarsh/VAEAS2/design/multest_devchk/adc_cascode_opamp_sim/maestro_4_2_setup/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<psfdir>/servers/esd_noida/saidarsh/VAEAS2/simulation/multest_devchk/adc_cascode_opamp_sim/maestro_4_2_setup/results/maestro/$AXL_HISTORY_NAME</psfdir>
			<simdir>$AXL_PROJECT_DIR/multest_devchk/adc_cascode_opamp_sim/maestro_4_2_setup/results/maestro/$AXL_HISTORY_NAME</simdir>
			<historyPsfSize>Not Computed</historyPsfSize>
		</historyentry>
		<historyentry assemblerOrExplorer="assembler" roOrView="view" runningOrFinished="finished">Interactive.3
			<timestamp>Jul 1 16:37:27 2025</timestamp>
			<uuid>{d6084902-e8a0-49d4-820e-7043c49a43c6}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/servers/esd_noida/saidarsh/VAEAS2/design/multest_devchk/adc_cascode_opamp_sim/maestro_4_2_setup/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<psfdir>/servers/esd_noida/saidarsh/VAEAS2/simulation/multest_devchk/adc_cascode_opamp_sim/maestro_4_2_setup/results/maestro/$AXL_HISTORY_NAME</psfdir>
			<simdir>$AXL_PROJECT_DIR/multest_devchk/adc_cascode_opamp_sim/maestro_4_2_setup/results/maestro/$AXL_HISTORY_NAME</simdir>
			<historyPsfSize>Not Computed</historyPsfSize>
		</historyentry>
		<historyentry assemblerOrExplorer="assembler" roOrView="view" runningOrFinished="finished">Interactive.4
			<timestamp>Jul 1 16:38:32 2025</timestamp>
			<uuid>{bbf864f4-62c4-4512-b3b6-3d50e2d39ff1}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/servers/esd_noida/saidarsh/VAEAS2/design/multest_devchk/adc_cascode_opamp_sim/maestro_4_2_setup/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<psfdir>/servers/esd_noida/saidarsh/VAEAS2/simulation/multest_devchk/adc_cascode_opamp_sim/maestro_4_2_setup/results/maestro/$AXL_HISTORY_NAME</psfdir>
			<simdir>$AXL_PROJECT_DIR/multest_devchk/adc_cascode_opamp_sim/maestro_4_2_setup/results/maestro/$AXL_HISTORY_NAME</simdir>
			<historyPsfSize>Not Computed</historyPsfSize>
		</historyentry>
		<historyentry assemblerOrExplorer="assembler" roOrView="view" runningOrFinished="finished">Interactive.5
			<timestamp>Jul 1 16:39:59 2025</timestamp>
			<uuid>{c6c38a12-95a8-4d23-894b-72c881f05b38}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/servers/esd_noida/saidarsh/VAEAS2/design/multest_devchk/adc_cascode_opamp_sim/maestro_4_2_setup/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<psfdir>/servers/esd_noida/saidarsh/VAEAS2/simulation/multest_devchk/adc_cascode_opamp_sim/maestro_4_2_setup/results/maestro/$AXL_HISTORY_NAME</psfdir>
			<simdir>$AXL_PROJECT_DIR/multest_devchk/adc_cascode_opamp_sim/maestro_4_2_setup/results/maestro/$AXL_HISTORY_NAME</simdir>
			<historyPsfSize>Not Computed</historyPsfSize>
		</historyentry>
	</history>
</setupdb>
